# IAR project WS2812B.ewp, settings and files
configuration WS2812B (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: ..\Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\Drivers\WS2812B\Inc; ..\Drivers\Buttons\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: WS2812B.hex
  ILINK.IlinkOutputFile: WS2812B.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xb.s
  group Application/EWARM/Drivers/Button
    ../Drivers/Buttons/Src/: button.c
    ../Drivers/Buttons/Inc/: button.h
  group Application/EWARM/Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Application/EWARM/Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Application/EWARM/Drivers/WS2812B
    ../Drivers/WS2812B/Src/: ws2812b.c
    ../Drivers/WS2812B/Inc/: ws2812b.h
  group Application/User/Inc
    ../Inc/: bulli.h events.h main.h queue.h stm32f1xx_hal_conf.h stm32f1xx_it.h
  group Application/User/Src
    ../Src/: bulli.c main.c queue.c stm32f1xx_hal_msp.c stm32f1xx_it.c
